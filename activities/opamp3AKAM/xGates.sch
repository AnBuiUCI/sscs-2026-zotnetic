v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 70 -130 70 -100 {lab=VDD}
N 70 0 70 60 {lab=VSS}
C {/foss/designs/sscs-2026-zotnetic/activities/opamp3AKAM/andGate.sym} 90 -30 0 0 {name=x1}
C {ipin.sym} 30 -70 0 0 {name=p4 lab=XY}
C {opin.sym} 120 -50 0 0 {name=p10 lab=output}
C {ipin.sym} 70 -130 0 0 {name=p1 lab=VDD}
C {ipin.sym} 70 60 0 0 {name=p2 lab=VSS}
C {ipin.sym} 30 -30 0 0 {name=p5 lab=XZ}
