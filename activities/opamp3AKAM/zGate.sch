v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {/foss/designs/sscs-2026-zotnetic/activities/opamp3AKAM/nor.sym} 70 -10 0 0 {name=x1}
C {ipin.sym} -80 0 0 0 {name=p4 lab=YZ}
C {ipin.sym} -80 -40 0 0 {name=p1 lab=XZ}
C {ipin.sym} -80 -20 0 0 {name=p2 lab=VDD}
C {ipin.sym} -80 20 0 0 {name=p3 lab=VSS}
C {opin.sym} 220 -40 0 0 {name=p10 lab=output}
