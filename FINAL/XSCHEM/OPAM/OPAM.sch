v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {ipin.sym} 40 -60 0 0 {name=p1 lab=IN-}
C {ipin.sym} 40 -20 0 0 {name=p2 lab=IN+}
C {iopin.sym} -10 -90 0 0 {name=p3 lab=VDD}
C {iopin.sym} -10 20 0 0 {name=p4 lab=VSS}
C {iopin.sym} 170 -50 0 0 {name=p5 lab=OUT}
