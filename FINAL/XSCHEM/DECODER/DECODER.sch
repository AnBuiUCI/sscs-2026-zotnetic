v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {ipin.sym} -310 -110 0 0 {name=p1 lab=XY}
C {ipin.sym} 180 -110 0 0 {name=p2 lab=XZ}
C {iopin.sym} 250 -140 0 0 {name=p3 lab=VDD}
C {iopin.sym} 250 -60 0 0 {name=p4 lab=VSS}
C {iopin.sym} -140 -100 0 0 {name=p5 lab=X}
C {ipin.sym} 180 -90 0 0 {name=p6 lab=YZ}
C {iopin.sym} 100 -110 0 0 {name=p7 lab=Y}
C {iopin.sym} 330 -100 0 0 {name=p8 lab=Z}
C {a_zonetic2026/XSCHEM/DECODER/Z.sym} 330 -90 0 0 {name=x1}
C {lab_pin.sym} -70 -90 0 0 {name=p9 sig_type=std_logic lab=XY}
C {lab_pin.sym} -310 -80 0 0 {name=p10 sig_type=std_logic lab=XZ}
C {lab_pin.sym} -70 -120 0 0 {name=p11 sig_type=std_logic lab=YZ}
C {lab_pin.sym} -230 -140 0 0 {name=p12 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -230 -50 0 0 {name=p13 sig_type=std_logic lab=VSS}
C {a_zonetic2026/XSCHEM/DECODER/yGates.sym} 10 -100 0 0 {name=x2}
C {a_zonetic2026/XSCHEM/DECODER/xGates.sym} -160 -80 0 0 {name=x3}
C {lab_pin.sym} 10 -150 0 0 {name=p14 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 10 -60 0 0 {name=p15 sig_type=std_logic lab=VSS}
